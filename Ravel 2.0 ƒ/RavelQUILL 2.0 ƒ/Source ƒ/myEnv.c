#include "myEnv.h"


short myOpenWD ( StringPtr workPath )
{
	WDPBRec		pbr;							/* local pb */


	pbr.ioNamePtr = workPath;
	pbr.ioWDProcID = 0L;
	pbr.ioWDDirID = 0L;
	pbr.ioVRefNum = 0;
	
	if ( PBOpenWDSync (&pbr) )
	{
		return 0;
	}
	
	return pbr.ioVRefNum;
}


short OpenAnyDir (OSType WhatFolder, short *VolRefNum, long *foundDirID)
{
	register OSErr err;

	err = FindFolder ( kOnSystemDisk, WhatFolder, kDontCreateFolder,
						VolRefNum, foundDirID );
//	if (!err)
//	{
//		err = OpenWD ( *foundVRefNum, *foundDirID, 0, wdRefNum );
//		return err;
//	}
	return err;
}


void myCloseWD ( short wdRefNum )
{
	WDPBRec		pbr;							/* local pb */


	pbr.ioVRefNum = wdRefNum;
	PBCloseWDSync (&pbr);
}

/*
asm unsigned short endshort ( short s )
{
	
		move.w		4(sp), d0
		ror.w		#8, d0
		rts
}

asm unsigned long endlong ( long s )
{
	
		move.w		4(sp), d0
		ror.w		#8, d0
		swap		d0
		ror.w		#8, d0
		rts
}
*/

short get_folder (StringPtr namepath, short *vRef, long *dirID)
{
	WDPBRec		pbr;							/* local pb */
	short		wdRefNum;
	short		err;
	

	pbr.ioCompletion = NULL;
	pbr.ioNamePtr = namepath;
	pbr.ioWDProcID = 'RvlS';
	pbr.ioWDDirID = 0L;
	pbr.ioVRefNum = 0;
	
	if (err = PBOpenWDSync (&pbr))
	{
		return err;
	}
	
	wdRefNum = pbr.ioVRefNum;
	
	pbr.ioCompletion = NULL;
	pbr.ioNamePtr = NULL;
	pbr.ioWDProcID = 'RvlS';
	pbr.ioWDIndex = 0;
	pbr.ioVRefNum = wdRefNum;
	pbr.ioWDVRefNum = 0;

	if ((err = PBGetWDInfoSync (&pbr)) == noErr)
	{
		*vRef = pbr.ioWDVRefNum;
		*dirID = pbr.ioWDDirID;
	}
	
	pbr.ioCompletion = NULL;
	pbr.ioNamePtr = NULL;
	pbr.ioWDProcID = 'RvlS';
	pbr.ioWDDirID = 0L;
	pbr.ioVRefNum = wdRefNum;
	PBCloseWDSync (&pbr);

	return err;
}


