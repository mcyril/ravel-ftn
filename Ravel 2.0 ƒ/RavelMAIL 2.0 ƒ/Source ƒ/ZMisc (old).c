
#include <stdio.h>
#include <ctype.h>

#include "ZMisc.h"
#include "Modem.h"
#include "Timing.h"
#include "Port.h"

#include "pmain.h"


/*
 * Data
 */

extern Boolean	busy;
extern short	cur_baud;

short Rxtimeout;           /* Tenths of seconds to wait
                          * for something          */


/*--------------------------------------------------------------------------*/
/* Z GET BYTE                                                               */
/* Get a byte from the modem;                                               */
/* return TIMEOUT if no read within timeout tenths,                         */
/* return RCDO if carrier lost                                              */
/*--------------------------------------------------------------------------*/

short Z_GetByte (short tenths)
{
	long timeout;
	
	if (tenths)
		timeout = timerset (tenths);
	
	while ( !CHAR_AVAIL() && !(tenths && timeup (timeout)) )
	{													// **************** ++++++++++
		if (CheckCancel())
			return -1;
		time_release ();								/* Wait up to 10 seconds */
	}
	
	if (tenths && timeup (timeout))
		return -2;
	else
		return MODEM_IN ();
}

