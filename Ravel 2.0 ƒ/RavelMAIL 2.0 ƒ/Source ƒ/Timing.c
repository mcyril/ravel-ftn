/*
**
**	Macintosh time service by Wicked Cyril
**
*/

#include "Timing.h"
//#include "Port.h"
#include "Comm.h"
#include "pmain.h"

extern short	delaing;

void timer ( long sleep )
{
	long		nowis = timerset (sleep);
	EventRecord	event;
	
	delaing = 1;
	
	do {
		
		WaitNextEvent (everyEvent, &event, gSleepTime, NULL);
		DoEvent(&event);
		
	} while (!timeup (nowis));

	delaing = 0;
}

long timerset ( long ths )
{
	return LMGetTicks () + ths;
}

Boolean timeup ( long end_time )
{
	return LMGetTicks () > end_time;
}

void time_release (void)
{
//	long		nowis;

	timer (30);						//	was 60

//	Delay ( 60, &nowis );			// sleep 1sec
}

void big_pause (short secs)
{
	long timeout;

	timeout = timerset ((long)secs * 60);

	while (!timeup (timeout))
	{
		if (CHAR_AVAIL ())
			break;
	
		time_release ();
	}
}

