
#include "ZipIt.h"

//	void DoSlice (void);


// Constants for dealing with FinderEvents. See Chapter 8 of the Apple Event
// Registry for more information.

#define kFinderSig	'FNDR'
#define kAEFinderEvents	'FNDR'
#define kSystemType	'MACS'

#define kAEOpenSelection	'sope'
#define keySelection	'fsel'

// Search through the current process list to find the given application. See
// Using the Process Manager for a similar way of doing this.
OSErr FindAProcess (OSType typeToFind, OSType creatorToFind,
			ProcessSerialNumberPtr processSN)
{
	ProcessInfoRec	tempInfo;
	FSSpec	procSpec;
	Str31		processName;
	OSErr		myErr = noErr;

	// start at the beginning of the process list
	processSN->lowLongOfPSN = kNoProcess;
	processSN->highLongOfPSN = 0;

	// initialize the process information record
	tempInfo.processInfoLength = sizeof(ProcessInfoRec);
	tempInfo.processName = (StringPtr)&processName;
	tempInfo.processAppSpec = &procSpec;

//	while((tempInfo.processSignature != creatorToFind ||
//			tempInfo.processType != typeToFind) ||
//			myErr != noErr)
	
	do {

		myErr = GetNextProcess (processSN);
		if (myErr == noErr)
		{
			GetProcessInformation(processSN, &tempInfo);
			if (tempInfo.processSignature == creatorToFind &&
				tempInfo.processType == typeToFind)
				break;
		}
		
	} while (myErr == noErr);
	
	return(myErr);
}

