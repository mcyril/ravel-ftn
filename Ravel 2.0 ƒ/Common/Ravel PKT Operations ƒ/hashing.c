#include "hashing.h"

#define POLY 0x48000000L

static long CrcTable[128];

void crcinit (void)
{
   int i, j;
   long sum;

   for (i = 0; i < 128; ++i) {
      sum = 0;
      for (j = 7 - 1; j >= 0; --j)
         if (i & (1 << j))
            sum ^= POLY >> j;
      CrcTable[i] = sum;
   }
}

/* Honeyman's nice hashing function
 */
long hash (register char *name, register int size)
{
   register long sum;

   if (size <= 0)
      return 0;

   sum = CrcTable[*name++ & 0x7f];

   while (--size)
      sum = (sum >> 7) ^ CrcTable[((char)sum ^ *name++) & 0x7f];

   return (sum);
}

