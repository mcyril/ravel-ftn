//	е	py_shuffler_prefs_route.c

#include "py_shuffler_prefs_route.h"

static void
prefroute_dealloc(PyPrefRouteObject *v)
{
	_Py_Dealloc(v->mask);
	_Py_Dealloc(v->routeto);

	PyObject_Del(v);
}

static int
prefroute_init(PyPrefRouteObject *v, PyObject *args, PyObject *kwds)
{
	v->mask = NULL;
	v->routeto = NULL;

	return 0;
}

static PyObject *
prefroute_getattr(PyPrefRouteObject *v, char *name)
{
	if (strcmp(name, "mask") == 0)
	{
		Py_XINCREF(v->mask);
		return v->mask;
	}
	else if (strcmp(name, "routeto") == 0)
	{
		Py_XINCREF(v->routeto);
		return v->routeto;
	}

	return NULL;
}

static int
prefroute_setattr(PyPrefRouteObject *v, char *name, PyObject *content)
{
	int res = -1;

	return res;
}

static PyPrefRouteObject *
prefroute_new_ex(void)
{
	PyPrefRouteObject *res = PyObject_New(PyPrefRouteObject, &PyShufflerPrefRoute_Type);
	if (res != NULL)
		prefroute_init(res, NULL, NULL);

	return res;
}

static PyObject *
prefroute_repr(PyPrefRouteObject *v)
{

}

PyTypeObject PyShufflerPrefRoute_Type = {

	PyObject_HEAD_INIT(&PyType_Type)
	0,
	"route",
	sizeof(PyPrefRouteObject),
	0,
	(destructor)prefroute_dealloc,
						/* tp_dealloc */
	0,					/* tp_print */
	(getattrfunc)prefroute_getattr,
						/* tp_getattr */
	0 /*(setattrfunc)prefroute_setattr*/,
						/* tp_setattr */
	0,					/* tp_compare */
	0 /*(reprfunc)prefroute_repr*/,
						/* tp_repr */
	0,					/* tp_as_number */
	0,					/* tp_as_sequence */
	0,					/* tp_as_mapping */
	0,					/* tp_hash */
	0,					/* tp_call */
	0,					/* tp_str */
	0,					/* tp_getattro */
	0,					/* tp_setattro */
	0,					/* tp_as_buffer */
	Py_TPFLAGS_DEFAULT,	/* tp_flags */
	0,					/* tp_doc */
	0,					/* tp_traverse */
	0,					/* tp_clear */
	0,					/* tp_richcompare */
	0,					/* tp_weaklistoffset */
	0,					/* tp_iter */
	0,					/* tp_iternext */
	0,					/* tp_methods */
	0,					/* tp_members */
	0,					/* tp_getset */
	0,					/* tp_base */
	0,					/* tp_dict */
	0,					/* tp_descr_get */
	0,					/* tp_descr_set */
	0,					/* tp_dictoffset */
	0,					/* tp_init */
	0,					/* tp_alloc */
	0,					/* tp_new */
};

PyObject *
PyShufflerPrefRouting_Create(plugsPrefs *pp)
{
	short	i, j;
	PyObject *res;

	res = PyList_New((**pp->Routing).routes);
	for (i = 0; i < (**pp->Routing).routes; i++)
	{
		PyPrefRouteObject *route = prefroute_new_ex();
		if(route != NULL)
		{
			route->mask = PyFtnMask_NewAddr(&(**pp->Routing).route[i].mask);
			route->routeto = PyFtnAddr_NewAddr(&(**pp->nodesHndls[(**pp->Routing).route[i].node]).Addr);
			
			PyList_SetItem(res, i, (PyObject *)route);
		}
	}

	Py_XINCREF(res);
	return res;
}
