//	е	py_shuffler_prefs_mail.c

#include "py_shuffler_prefs_mail.h"

#include "PascalStr.h"

static void
prefmail_dealloc(PyPrefMailObject *v)
{
	_Py_Dealloc(v->useAKA);

	PyObject_Del(v);
}

static int
prefmail_init(PyPrefMailObject *v, PyObject *args, PyObject *kwds)
{
	v->mailName[0] = 0;
	v->areaflags = 0;
	v->purger = 0;

	v->useAKA = NULL;

	return 0;
}

static PyObject *
prefmail_getattr(PyPrefMailObject *v, char *name)
{
	if (strcmp(name, "name") == 0)
		return PyString_FromStringAndSize((char *)&v->mailName[1], v->mailName[0]);
	else if (strcmp(name, "flags") == 0)
		return PyInt_FromLong(v->areaflags);
	else if (strcmp(name, "purgedays") == 0)
		return PyInt_FromLong(v->purger);
	else if (strcmp(name, "useaka") == 0)
	{
		Py_XINCREF(v->useAKA);
		return v->useAKA;
	}

	return NULL;
}

static int
prefmail_setattr(PyPrefMailObject *v, char *name, PyObject *content)
{
	int res = -1;

	return res;
}

static PyPrefMailObject *
prefmail_new_ex(void)
{
	PyPrefMailObject *res = PyObject_New(PyPrefMailObject, &PyShufflerPrefMail_Type);
	if (res != NULL)
		prefmail_init(res, NULL, NULL);

	return res;
}

static PyObject *
prefmail_repr(PyPrefMailObject *v)
{
	return PyString_FromStringAndSize((char *)&v->mailName[1], v->mailName[0]);
}

PyTypeObject PyShufflerPrefMail_Type = {

	PyObject_HEAD_INIT(&PyType_Type)
	0,
	"mail",
	sizeof(PyPrefMailObject),
	0,
	(destructor)prefmail_dealloc,
						/* tp_dealloc */
	0,					/* tp_print */
	(getattrfunc)prefmail_getattr,
						/* tp_getattr */
	0 /*(setattrfunc)prefmail_setattr*/,
						/* tp_setattr */
	0,					/* tp_compare */
	(reprfunc)prefmail_repr,
						/* tp_repr */
	0,					/* tp_as_number */
	0,					/* tp_as_sequence */
	0,					/* tp_as_mapping */
	0,					/* tp_hash */
	0,					/* tp_call */
	0,					/* tp_str */
	0,					/* tp_getattro */
	0,					/* tp_setattro */
	0,					/* tp_as_buffer */
	Py_TPFLAGS_DEFAULT,	/* tp_flags */
	0,					/* tp_doc */
	0,					/* tp_traverse */
	0,					/* tp_clear */
	0,					/* tp_richcompare */
	0,					/* tp_weaklistoffset */
	0,					/* tp_iter */
	0,					/* tp_iternext */
	0,					/* tp_methods */
	0,					/* tp_members */
	0,					/* tp_getset */
	0,					/* tp_base */
	0,					/* tp_dict */
	0,					/* tp_descr_get */
	0,					/* tp_descr_set */
	0,					/* tp_dictoffset */
	0,					/* tp_init */
	0,					/* tp_alloc */
	0,					/* tp_new */
};

PyObject *
PyShufflerPrefMail_Create(plugsPrefs *pp)
{
	short	i;

	PyPrefMailObject *res = prefmail_new_ex();
	if(res != NULL)
	{
		pStrCopy((**pp->mailHndl).mailName, res->mailName);
		
		res->areaflags = (**pp->mailHndl).areaflags;
		res->purger = (**pp->mailHndl).purger;

		res->useAKA = ((**pp->mailHndl).useAKA == 0) ?
				PyFtnAddr_NewAddr(&(**pp->homesystem).mainAddr.ad) :
				PyFtnAddr_NewAddr(&(**pp->homesystem).AKAAddr[(**pp->mailHndl).useAKA - 1].ad);
	}

	Py_XINCREF(res);
	return (PyObject *)res;
}
