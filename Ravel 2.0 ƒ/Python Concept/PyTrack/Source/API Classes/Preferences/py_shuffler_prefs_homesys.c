//	е	py_shuffler_prefs_homesys.c

#include "py_shuffler_prefs_homesys.h"

#include "PascalStr.h"

static void
prefhomesys_dealloc(PyPrefHomeSysObject *v)
{
	_Py_Dealloc(v->mainAddr);
	_Py_Dealloc(v->AKAAddr);

	PyObject_Del(v);
}

static int
prefhomesys_init(PyPrefHomeSysObject *v, PyObject *args, PyObject *kwds)
{
	v->system[0] = 0;
	v->sysop[0] = 0;
	v->location[0] = 0;
	v->phone[0] = 0;
	v->baud[0] = 0;
	v->emsi_flags[0] = 0;

	v->mainAddr = NULL;
	v->AKAAddr = NULL;

	return 0;
}

static PyObject *
prefhomesys_getattr(PyPrefHomeSysObject *v, char *name)
{
	if (strcmp(name, "sysname") == 0)
		return PyString_FromStringAndSize((char *)&v->system[1], v->system[0]);
	else if (strcmp(name, "sysop") == 0)
		return PyString_FromStringAndSize((char *)&v->sysop[1], v->sysop[0]);
	else if (strcmp(name, "location") == 0)
		return PyString_FromStringAndSize((char *)&v->location[1], v->location[0]);
	else if (strcmp(name, "phone") == 0)
		return PyString_FromStringAndSize((char *)&v->phone[1], v->phone[0]);
	else if (strcmp(name, "baud") == 0)
		return PyString_FromStringAndSize((char *)&v->baud[1], v->baud[0]);
	else if (strcmp(name, "emsi_flags") == 0)
		return PyString_FromStringAndSize((char *)&v->emsi_flags[1], v->emsi_flags[0]);
	else if (strcmp(name, "address") == 0)
	{
		Py_XINCREF(v->mainAddr);
		return v->mainAddr;
	}
	else if (strcmp(name, "aka") == 0)
	{
		Py_XINCREF(v->AKAAddr);
		return v->AKAAddr;
	}

	return NULL;
}

static int
prefhomesys_setattr(PyPrefHomeSysObject *v, char *name, PyObject *content)
{
	int res = -1;

	return res;
}

static PyPrefHomeSysObject *
prefhomesys_new_ex(void)
{
	PyPrefHomeSysObject *res = PyObject_New(PyPrefHomeSysObject, &PyShufflerPrefHomeSys_Type);
	if (res != NULL)
		prefhomesys_init(res, NULL, NULL);

	return res;
}

PyTypeObject PyShufflerPrefHomeSys_Type = {

	PyObject_HEAD_INIT(&PyType_Type)
	0,
	"home",
	sizeof(PyPrefHomeSysObject),
	0,
	(destructor)prefhomesys_dealloc,
						/* tp_dealloc */
	0,					/* tp_print */
	(getattrfunc)prefhomesys_getattr,
						/* tp_getattr */
	0 /*(setattrfunc)prefhomesys_setattr*/,
						/* tp_setattr */
	0,					/* tp_compare */
	0,					/* tp_repr */
	0,					/* tp_as_number */
	0,					/* tp_as_sequence */
	0,					/* tp_as_mapping */
	0,					/* tp_hash */
	0,					/* tp_call */
	0,					/* tp_str */
	0,					/* tp_getattro */
	0,					/* tp_setattro */
	0,					/* tp_as_buffer */
	Py_TPFLAGS_DEFAULT,	/* tp_flags */
	0,					/* tp_doc */
	0,					/* tp_traverse */
	0,					/* tp_clear */
	0,					/* tp_richcompare */
	0,					/* tp_weaklistoffset */
	0,					/* tp_iter */
	0,					/* tp_iternext */
	0,					/* tp_methods */
	0,					/* tp_members */
	0,					/* tp_getset */
	0,					/* tp_base */
	0,					/* tp_dict */
	0,					/* tp_descr_get */
	0,					/* tp_descr_set */
	0,					/* tp_dictoffset */
	0,					/* tp_init */
	0,					/* tp_alloc */
	0,					/* tp_new */
};

PyObject *
PyShufflerPrefHomeSys_Create(plugsPrefs *pp)
{
	short	i;

	PyPrefHomeSysObject *res = prefhomesys_new_ex();
	if(res != NULL)
	{
		pStrCopy((**pp->homesystem).system, res->system);
		pStrCopy((**pp->homesystem).sysop, res->sysop);
		pStrCopy((**pp->homesystem).location, res->location);
		pStrCopy((**pp->homesystem).phone, res->phone);
		pStrCopy((**pp->homesystem).baud, res->baud);
		pStrCopy((**pp->homesystem).emsi_flags, res->emsi_flags);

		res->mainAddr = PyFtnAddr_NewAddr(&(**pp->homesystem).mainAddr.ad);
		
		res->AKAAddr = PyList_New((**pp->homesystem).AKAcount);
		Py_XINCREF(res->AKAAddr);
		for (i = 0; i < (**pp->homesystem).AKAcount; i++)
			PyList_SetItem(res->AKAAddr, i, PyFtnAddr_NewAddr(&(**pp->homesystem).AKAAddr[i].ad));
	}

	Py_XINCREF(res);
	return (PyObject *)res;
}
