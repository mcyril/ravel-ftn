//	е	py_plugparser_tkn.c

#include "py_plugparser_tkn.h"

static void
parsertoken_dealloc(PyParserTokenObject *v)
{
	PyObject_Del(v);
}

static int
parsertoken_init(PyParserTokenObject *v, PyObject *args, PyObject *kwds)
{
	v->token = 0;
	v->klass = 0;
	return 0;
}


static int
parsertoken_print(PyParserTokenObject *v, FILE *fp, int flags)
     /* flags -- not used but required by interface */
{
	if (v->klass != 0)
		fprintf(fp, "<%i:%i:%s>", v->token, v->klass, v->tokenname);
	else
		fprintf(fp, "<%i:%s>", v->token, v->tokenname);
	return 0;
}

static PyObject *
parsertoken_repr(PyParserTokenObject *v)
{
	char	temp[512];

	if (v->klass != 0)
		sprintf(temp, "<%i:%i:%s>", v->token, v->klass, v->tokenname);
	else
		sprintf(temp, "<%i:%s>", v->token, v->tokenname);
	return PyString_FromString(temp);
}

static PyObject *
parsertoken_getattr(PyParserTokenObject *v, char *name)
{
	if (strcmp(name, "id") == 0)
		return PyInt_FromLong(v->token);
	else if (strcmp(name, "class") == 0)
		return PyInt_FromLong(v->klass);
	else if (strcmp(name, "name") == 0)
		return PyString_FromString(v->tokenname);

	return NULL;
}

static int
parsertoken_setattr(PyParserTokenObject *v, char *name, PyObject *content)
{
	int res = -1;

	return res;
}

static PyObject *
parsertoken_new(PyTypeObject *type, PyObject *args, PyObject *kwds)
{
	int					i, klass = 0;
	PyParserTokenObject	*res;

	if (!PyArg_ParseTuple(args, "i|i", &i, &klass))
		return NULL;

	res = PyObject_New(PyParserTokenObject, &PyParserToken_Type);
	if (res != NULL)
	{
		res->token = i;
		res->klass = klass;
	}

	return (PyObject *)res;
}

PyTypeObject PyParserToken_Type = {

	PyObject_HEAD_INIT(&PyType_Type)
	0,
	"token",
	sizeof(PyParserTokenObject),
	0,
	(destructor)parsertoken_dealloc,
						/* tp_dealloc */
	(printfunc)parsertoken_print,
						/* tp_print */
	(getattrfunc)parsertoken_getattr,
						/* tp_getattr */
	(setattrfunc)parsertoken_setattr,
						/* tp_setattr */
	0,					/* tp_compare */
	(reprfunc)parsertoken_repr,
						/* tp_repr */
	0,					/* tp_as_number */
	0,					/* tp_as_sequence */
	0,					/* tp_as_mapping */
	0,					/* tp_hash */
	0,					/* tp_call */
	0,					/* tp_str */
	0,					/* tp_getattro */
	0,					/* tp_setattro */
	0,					/* tp_as_buffer */
	Py_TPFLAGS_DEFAULT | Py_TPFLAGS_BASETYPE,
						/* tp_flags */
	0,					/* tp_doc */
	0,					/* tp_traverse */
	0,					/* tp_clear */
	0,					/* tp_richcompare */
	0,					/* tp_weaklistoffset */
	0,					/* tp_iter */
	0,					/* tp_iternext */
	0,					/* tp_methods */
	0,					/* tp_members */
	0,					/* tp_getset */
	0,					/* tp_base */
	0,					/* tp_dict */
	0,					/* tp_descr_get */
	0,					/* tp_descr_set */
	0,					/* tp_dictoffset */
	(initproc)parsertoken_init,
						/* tp_init */
	0,					/* tp_alloc */
	parsertoken_new,	/* tp_new */
};

PyObject *
PyParsedToken_New(long token, long klass, char *name)
{
	PyParserTokenObject *res = PyObject_New(PyParserTokenObject, &PyParserToken_Type);
	if (res != NULL)
	{
		res->token = token;
		res->klass = klass;
		strncpy(res->tokenname, name, 255);
		res->tokenname[255] = 0;
	}
	return (PyObject *)res;
}
